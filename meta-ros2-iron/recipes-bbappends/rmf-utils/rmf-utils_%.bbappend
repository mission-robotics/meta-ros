FILES:${PN}:prepend = " \
    ${datadir}/ament_index \
"
