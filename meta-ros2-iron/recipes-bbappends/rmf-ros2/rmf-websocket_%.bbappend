DEPENDS += "\
    python3-numpy-native \
"
