FILES:${PN} += "${datadir}/ament_index"