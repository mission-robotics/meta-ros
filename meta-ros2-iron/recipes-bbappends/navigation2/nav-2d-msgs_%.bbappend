include navigation2.inc