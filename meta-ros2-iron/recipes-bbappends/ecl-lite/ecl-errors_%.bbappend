# ERROR: ecl-errors-1.2.0-4-r0 do_package_qa: QA Issue: non -dev/-dbg/nativesdk- package ecl-errors contains symlink .so '/usr/lib/libecl_errors.so' [dev-so]
inherit ros_insane_dev_so