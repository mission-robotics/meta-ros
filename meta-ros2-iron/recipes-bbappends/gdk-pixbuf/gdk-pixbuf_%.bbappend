EXTRA_OEMESON:class-native:append = " -Dtests=false -Dman=false"
