QT_CONFIG_FLAGS:remove = " \
    -no-accessibility \
    -no-opengl \
"