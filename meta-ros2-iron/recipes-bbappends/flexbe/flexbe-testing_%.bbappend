# ERROR: flexbe-testing-1.3.0-1-r0 do_package_qa: QA Issue: /opt/ros/melodic/lib/flexbe_testing/testing_node contained in package flexbe-testing requires /bin/bash, but no providers found in RDEPENDS:flexbe-testing? [file-rdeps]
RDEPENDS:${PN} += "bash"
