RDEPENDS:${PN} += "bash"