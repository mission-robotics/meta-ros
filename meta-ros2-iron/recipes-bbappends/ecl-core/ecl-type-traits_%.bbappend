# ERROR: ecl-type-traits-1.2.1-4-r0 do_package_qa: QA Issue: non -dev/-dbg/nativesdk- package ecl-type-traits contains symlink .so '/usr/lib/libecl_type_traits.so' [dev-so]
inherit ros_insane_dev_so