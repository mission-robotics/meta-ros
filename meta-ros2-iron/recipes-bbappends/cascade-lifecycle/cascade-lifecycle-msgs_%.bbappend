ROS_BUILD_DEPENDS = " \
    rosidl-core-generators-native \
    rosidl-adapter-native \
    rosidl-parser-native \
    python3-numpy-native \
    python3-lark-parser-native \
    rpyutils-native \
"