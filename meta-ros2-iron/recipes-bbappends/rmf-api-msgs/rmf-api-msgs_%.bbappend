ROS_BUILD_DEPENDS += " \
    python3-jinja2-native \
"

FILES:${PN} += "${datadir}/schemas/*"